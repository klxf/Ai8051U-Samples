# Keil uVision project Project.uvproj, settings and files
target Target_1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: Project +hex
  group Source Group 1
    ./: main.c oled.c delay.c minimax.c
